# Keil uVision project USB_DEMO.uvprojx, settings and files
target USB_DEMO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_DEMO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_STM3210C_EVAL
  c include: ..\lib\inc;..\usb\STM32_USB_HOST_Library\Class\HID\inc;..\usb\STM32_USB_HOST_Library\Core\inc;..\stm32f107\Common;..\stm32f107\STM3210C_EVAL;..\user\HID\inc;..\usb\STM32_USB_OTG_Driver\inc;..\hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/HID/src/: main.c stm32fxxx_it.c system_stm32f10x.c usb_bsp.c usbh_usr.c usbh_usr_lcd.c
  group stm32f107
    ../stm32f107/Common/: lcd_log.c
    ../stm32f107/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_lcd.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../startup/: startup_stm32f10x_cl.s
  group usb_core
    ../usb/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group usb_hid
    ../usb/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c
  group usb_driver
    ../usb/STM32_USB_OTG_Driver/src/: usb_hcd.c usb_hcd_int.c usb_core.c
  group hardware
    ../hardware/src/: led.c usart.c
